v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Lengths are scaled to um} 140 -460 0 0 0.4 0.4 {}
T {2I} 970 -360 0 0 0.4 0.4 {}
T {2I} 1210 -360 0 0 0.4 0.4 {}
T {2I} 1210 -700 0 0 0.4 0.4 {}
T {I} 1410 -700 0 0 0.4 0.4 {}
T {I} 1540 -700 0 0 0.4 0.4 {}
T {I} 970 -520 0 0 0.4 0.4 {}
T {I} 1220 -520 0 0 0.4 0.4 {}
N 1000 -640 1000 -620 {
lab=Vc1}
N 1120 -640 1240 -640 {
lab=Vc1}
N 1240 -640 1240 -620 {
lab=Vc1}
N 1000 -260 1000 -240 {
lab=Vss}
N 1000 -240 1240 -240 {
lab=Vss}
N 1240 -260 1240 -240 {
lab=Vss}
N 1120 -660 1120 -640 {
lab=Vc1}
N 1000 -640 1120 -640 {
lab=Vc1}
N 1000 -380 1000 -320 {
lab=Vc2}
N 1040 -290 1200 -290 {
lab=Vbn1}
N 740 -740 740 -720 {
lab=Vdd}
N 860 -740 1120 -740 {
lab=Vdd}
N 1120 -740 1120 -720 {
lab=Vdd}
N 740 -640 740 -320 {
lab=Vbp1}
N 740 -260 740 -240 {
lab=Vss}
N 860 -240 1000 -240 {
lab=Vss}
N 1240 -340 1240 -320 {
lab=Vt1}
N 700 -690 740 -690 {
lab=Vdd}
N 960 -290 1000 -290 {
lab=Vss}
N 1200 -590 1240 -590 {
lab=Vdd}
N 1000 -590 1040 -590 {
lab=Vdd}
N 1120 -690 1160 -690 {
lab=Vdd}
N 1240 -290 1280 -290 {
lab=Vss}
N 800 -690 800 -640 {
lab=Vbp1}
N 780 -690 800 -690 {
lab=Vbp1}
N 740 -640 800 -640 {
lab=Vbp1}
N 740 -660 740 -640 {
lab=Vbp1}
N 800 -980 800 -960 {
lab=Vdd}
N 800 -890 800 -880 {
lab=GND}
N 860 -980 860 -960 {
lab=Vss}
N 800 -900 800 -890 {
lab=GND}
N 860 -900 860 -890 {
lab=GND}
N 800 -890 860 -890 {
lab=GND}
N 1040 -890 1100 -890 {
lab=GND}
N 1100 -900 1100 -890 {
lab=GND}
N 1100 -980 1100 -960 {
lab=Vph}
N 1100 -890 1170 -890 {
lab=GND}
N 1170 -900 1170 -890 {
lab=GND}
N 1230 -960 1230 -950 {
lab=Vcm}
N 1170 -960 1230 -960 {
lab=Vcm}
N 1230 -970 1230 -960 {
lab=Vcm}
N 1440 -740 1560 -740 {
lab=Vdd}
N 1560 -590 1600 -590 {
lab=Vdd}
N 1560 -430 1600 -430 {
lab=Vss}
N 1400 -430 1440 -430 {
lab=Vss}
N 1400 -510 1440 -510 {
lab=Vdd}
N 1560 -510 1600 -510 {
lab=Vdd}
N 1400 -590 1440 -590 {
lab=Vdd}
N 1480 -510 1520 -510 {
lab=Vbp1}
N 1480 -430 1520 -430 {
lab=Vbn2}
N 1490 -590 1490 -470 {
lab=Vbp3}
N 1490 -590 1520 -590 {
lab=Vbp3}
N 1440 -470 1440 -460 {
lab=Vbp3}
N 1440 -480 1440 -470 {
lab=Vbp3}
N 1480 -590 1490 -590 {
lab=Vbp3}
N 1440 -470 1490 -470 {
lab=Vbp3}
N 1440 -560 1440 -540 {
lab=#net1}
N 1560 -560 1560 -540 {
lab=Vt2}
N 1560 -470 1560 -460 {
lab=Vdo}
N 1440 -650 1440 -620 {
lab=#net2}
N 1440 -740 1440 -710 {
lab=Vdd}
N 1120 -740 1440 -740 {
lab=Vdd}
N 1560 -740 1560 -620 {
lab=Vdd}
N 1440 -400 1440 -380 {
lab=Vc2}
N 1000 -380 1440 -380 {
lab=Vc2}
N 1560 -400 1560 -340 {
lab=Vt1}
N 1240 -340 1560 -340 {
lab=Vt1}
N 1240 -560 1240 -340 {
lab=Vt1}
N 1560 -470 1600 -470 {
lab=Vdo}
N 1560 -480 1560 -470 {
lab=Vdo}
N 920 -980 920 -960 {
lab=#net3}
N 920 -900 920 -890 {
lab=GND}
N 860 -890 920 -890 {
lab=GND}
N 980 -980 980 -960 {
lab=#net4}
N 980 -900 980 -890 {
lab=GND}
N 920 -890 980 -890 {
lab=GND}
N 1040 -980 1040 -960 {
lab=#net5}
N 1040 -900 1040 -890 {
lab=GND}
N 980 -890 1040 -890 {
lab=GND}
N 1000 -560 1000 -540 {
lab=#net6}
N 1000 -480 1000 -380 {
lab=Vc2}
N 1060 -690 1080 -690 {
lab=Vbp1}
N 860 -690 900 -690 {
lab=Vdd}
N 800 -690 820 -690 {
lab=Vbp1}
N 860 -260 860 -240 {
lab=Vss}
N 820 -290 860 -290 {
lab=Vss}
N 740 -240 860 -240 {
lab=Vss}
N 860 -330 860 -320 {
lab=Vbn1}
N 900 -290 910 -290 {
lab=Vbn1}
N 910 -330 910 -290 {
lab=Vbn1}
N 860 -330 910 -330 {
lab=Vbn1}
N 860 -740 860 -720 {
lab=Vdd}
N 740 -740 860 -740 {
lab=Vdd}
N 820 -390 860 -390 {
lab=Vss}
N 860 -360 860 -330 {
lab=Vbn1}
N 860 -430 860 -420 {
lab=Vbn2}
N 860 -430 910 -430 {
lab=Vbn2}
N 910 -430 910 -390 {
lab=Vbn2}
N 900 -390 910 -390 {
lab=Vbn2}
N 860 -440 860 -430 {
lab=Vbn2}
N 860 -660 860 -500 {
lab=#net7}
N 1700 -690 1740 -690 {
lab=Vss}
N 1620 -690 1660 -690 {
lab=Vdo}
N 1700 -660 1700 -320 {
lab=Vdos}
N 1000 -130 1040 -130 {
lab=Vss}
N 1240 -130 1280 -130 {
lab=Vdd}
N 940 -130 960 -130 {
lab=Vc1}
N 1000 -180 1000 -160 {
lab=Vdd}
N 1000 -100 1000 -80 {
lab=Vc1s}
N 1240 -180 1240 -160 {
lab=Vc2s}
N 1240 -100 1240 -80 {
lab=Vss}
N 1560 -740 1700 -740 {
lab=Vdd}
N 1700 -740 1700 -720 {
lab=Vdd}
N 1180 -130 1200 -130 {
lab=Vc2}
N 1700 -260 1700 -240 {
lab=Vss}
N 1240 -240 1700 -240 {
lab=Vss}
C {sky130_fd_pr/corner.sym} 20 -430 0 0 {name=CORNER only_toplevel=yes corner=tt}
C {devices/launcher.sym} 90 -270 0 0 {name=h15
descr="Annotate OP" 
tclcommand="set show_hidden_texts 1; xschem annotate_op"
}
C {devices/launcher.sym} 90 -230 0 0 {name=h17 
descr="Load waves" 
tclcommand="
xschem raw_read $netlist_dir/[file tail [file rootname [xschem get current_name]]].raw dc
"
}
C {devices/code_shown.sym} 1920 -850 0 0 {name=NGSPICE
only_toplevel=true
value="* this option enables mos model bin 
* selection based on W/NF instead of W
.option wnflag=1
.option savecurrents acct abstol=1e-15
*reltol=1e-6
*gmin=1e-15

.control
save all
save @m.xm1.msky130_fd_pr__pfet_01v8_lvt[gm]
save @m.xm1.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm1.msky130_fd_pr__pfet_01v8_lvt[vdsat]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vdsat]
save @m.xm4.msky130_fd_pr__nfet_01v8_lvt[gm]
save @m.xm4.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm4.msky130_fd_pr__nfet_01v8_lvt[vdsat]

op
write CntDiffAmp1.raw

dc Vcm 0.0 1.8 0.01
plot v(Vdo) vs v(Vcm)
plot v(Vbp1), v(Vbp3) vs v(Vcm)
plot i(Va1), i(Va2) vs v(Vcm)
plot @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm], @m.xm4.msky130_fd_pr__nfet_01v8_lvt[gm] vs V(Vcm)

dc Vinp -1.0 1.0 0.01
plot v(Vdo), v(Vdos) vs v(Vinp)

dc Vbp2 0.0 1.8 0.01
plot i(Va1), i(Va2) vs v(Vbp2)

set appendwrite
write CntDiffAmp1.raw

ac dec 10 1 1e9
let dbVout = vdb(Vdos)
plot dbVout
meas AC GainAt10Hz FIND dbVout AT=10
meas AC FreqAt0dB WHEN dbVout=0
print GainAt10Hz, FreqAt0dB

write CntDiffAmp1.raw
.endc
"
}
C {devices/code.sym} 20 -580 0 0 {name=MODEL
only_toplevel=true
place=beginning
value="
** CntFET model
.subckt cntnfet_a d g s b
.param l=1 w=0.01 mult=1
mcntnfet_a d g s b cntnfet l=\{l\} w=\{w\}
* BSIM4 model
.model cntnfet nmos
+ level=54 version=4.8.2
+ toxe=7e-9
.ends cntnfet_a

.subckt cntpfet_a d g s b
.param l=1 w=0.01 mult=1
mcntpfet_a d g s b cntpfet l=\{l\} w=\{w\}
* BSIM4 model
.model cntpfet pmos
+ level=54 version=4.8.2
+ toxe=100e-9 U0=1.09e-4 VTH0=-2.02
.ends cntnfet_a

.model cntnfet_b nmos level=54 version=4.8.2 toxe=5e-9
.model cntpfet_b nmos level=54 version=4.8.2 toxe=5e-9
"}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1220 -290 0 0 {name=M5
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1020 -290 0 1 {name=M4
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 740 -240 0 0 {name=p12 sig_type=std_logic lab=Vss}
C {devices/isource.sym} 740 -290 0 0 {name=I0 value=10n only_toplevel=true}
C {devices/lab_pin.sym} 1600 -470 0 1 {name=p13 sig_type=std_logic lab=Vdo}
C {devices/lab_pin.sym} 740 -740 0 0 {name=p14 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 960 -290 0 0 {name=p16 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 1280 -290 0 1 {name=p17 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 1040 -590 0 1 {name=p18 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 1160 -690 0 1 {name=p19 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 1200 -590 0 0 {name=p15 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 700 -690 0 0 {name=p20 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 1230 -890 0 1 {name=p21 sig_type=std_logic lab=Vinn}
C {devices/lab_pin.sym} 960 -590 0 0 {name=p22 sig_type=std_logic lab=Vinp}
C {devices/vsource.sym} 800 -930 0 0 {name=Vdd value=1.8 only_toplevel=true}
C {devices/vsource.sym} 860 -930 0 0 {name=Vgnd value=0 only_toplevel=true}
C {devices/lab_pin.sym} 860 -980 0 0 {name=p23 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 800 -980 0 0 {name=p24 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 800 -880 0 0 {name=l1 lab=GND}
C {devices/vsource.sym} 1230 -1000 0 0 {name=Vinp value="0.0 ac 1" only_toplevel=true}
C {devices/vsource.sym} 1230 -920 0 0 {name=Vinn value=0.0 only_toplevel=true}
C {devices/lab_pin.sym} 1230 -1030 0 1 {name=p25 sig_type=std_logic lab=Vinp}
C {devices/lab_pin.sym} 1280 -590 0 1 {name=p26 sig_type=std_logic lab=Vinn}
C {devices/lab_pin.sym} 740 -640 0 0 {name=p27 sig_type=std_logic lab=Vbp1}
C {devices/lab_pin.sym} 1120 -290 1 1 {name=p28 sig_type=std_logic lab=Vbn1}
C {devices/lab_pin.sym} 1240 -640 0 1 {name=p29 sig_type=std_logic lab=Vc1}
C {devices/vsource.sym} 1100 -930 0 0 {name=Vph value=1.8 only_toplevel=true}
C {devices/lab_pin.sym} 1100 -980 0 1 {name=p30 sig_type=std_logic lab=Vph}
C {devices/vsource.sym} 1170 -930 0 0 {name=Vcm value=0.8 only_toplevel=true}
C {devices/ngspice_get_value.sym} 1060 -740 0 0 {name=r1 node=v(@m.$\{path\}xm1.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1120 -740 0 0 {name=r2 node=v(@m.$\{path\}xm1.msky130_fd_pr__pfet_01v8_lvt[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 950 -210 0 0 {name=r3 node=v(@m.$\{path\}xm4.msky130_fd_pr__nfet_01v8_lvt[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1000 -210 0 0 {name=r4 node=v(@m.$\{path\}xm4.msky130_fd_pr__nfet_01v8_lvt[vdsat])
descr="vdsat="}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1100 -690 0 0 {name=M1
L=5
W=2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 760 -690 0 1 {name=M15
L=5
W=10
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 980 -590 0 0 {name=M2
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1260 -590 0 1 {name=M3
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1540 -590 0 0 {name=M11
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 1600 -590 0 1 {name=p1 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1540 -430 0 0 {name=M7
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/ammeter.sym} 1440 -680 0 0 {name=Va2}
C {devices/lab_pin.sym} 1600 -430 0 1 {name=p5 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 1230 -960 0 1 {name=p3 sig_type=std_logic lab=Vcm}
C {devices/title.sym} 160 -30 0 0 {name=l2 author="Yuan Mei"}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1460 -430 0 1 {name=M6
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 1400 -430 0 0 {name=p2 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 1400 -510 0 0 {name=p4 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1460 -510 0 1 {name=M8
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1540 -510 0 0 {name=M9
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 1400 -590 0 0 {name=p6 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1460 -590 0 1 {name=M10
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 1510 -510 1 0 {name=p7 sig_type=std_logic lab=Vbp1}
C {devices/lab_pin.sym} 1500 -430 1 1 {name=p8 sig_type=std_logic lab=Vbn2}
C {devices/lab_pin.sym} 1600 -510 0 1 {name=p9 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 1510 -590 1 0 {name=p10 sig_type=std_logic lab=Vbp3}
C {devices/vsource.sym} 920 -930 0 0 {name=Vbn1 value=0.2 only_toplevel=true}
C {devices/lab_pin.sym} 860 -330 2 1 {name=p11 sig_type=std_logic lab=Vbn1}
C {devices/vsource.sym} 980 -930 0 0 {name=Vbn2 value=0.5 only_toplevel=true}
C {devices/vsource.sym} 1040 -930 0 0 {name=Vbp2 value=1.5 only_toplevel=true}
C {devices/lab_pin.sym} 1560 -340 0 1 {name=p33 sig_type=std_logic lab=Vt1}
C {devices/ammeter.sym} 1000 -510 0 0 {name=Va1}
C {devices/lab_pin.sym} 1060 -690 0 0 {name=p34 sig_type=std_logic lab=Vbp1}
C {devices/lab_pin.sym} 900 -690 0 1 {name=p35 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 840 -690 0 0 {name=M12
L=5
W=2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/ammeter.sym} 860 -470 0 0 {name=Va3}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 880 -290 0 1 {name=M14
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 820 -290 0 0 {name=p36 sig_type=std_logic lab=Vss}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 880 -390 0 1 {name=M13
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 820 -390 0 0 {name=p37 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 860 -430 2 1 {name=p38 sig_type=std_logic lab=Vbn2}
C {devices/lab_pin.sym} 1560 -550 0 1 {name=p31 sig_type=std_logic lab=Vt2}
C {devices/ipin.sym} 80 -790 0 0 {name=p32 lab=Vinp sim_pinnumber=4}
C {devices/opin.sym} 60 -820 0 0 {name=p39 lab=Vdo sim_pinnumber=3}
C {devices/ipin.sym} 80 -760 0 0 {name=p40 lab=Vinn sim_pinnumber=5}
C {devices/iopin.sym} 60 -880 0 0 {name=p41 lab=Vdd sim_pinnumber=1}
C {devices/iopin.sym} 60 -850 0 0 {name=p42 lab=Vss sim_pinnumber=2}
C {devices/iopin.sym} 60 -730 0 0 {name=p43 lab=Vbp1 sim_pinnumber=6}
C {devices/lab_pin.sym} 1000 -400 0 1 {name=p44 sig_type=std_logic lab=Vc2}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1680 -690 0 0 {name=M16
L=1
W=50
nf=10
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 1740 -690 0 1 {name=p45 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 1620 -690 0 0 {name=p46 sig_type=std_logic lab=Vdo}
C {devices/lab_pin.sym} 1700 -620 0 1 {name=p47 sig_type=std_logic lab=Vdos}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 980 -130 0 0 {name=M17
L=1
W=10
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 1040 -130 0 1 {name=p48 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 1280 -130 0 1 {name=p49 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1220 -130 0 0 {name=M18
L=1
W=10
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 940 -130 0 0 {name=p50 sig_type=std_logic lab=Vc1}
C {devices/lab_pin.sym} 1000 -180 0 0 {name=p51 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 1000 -80 0 0 {name=p52 sig_type=std_logic lab=Vc1s}
C {devices/lab_pin.sym} 1240 -80 0 0 {name=p53 sig_type=std_logic lab=Vss}
C {devices/lab_pin.sym} 1180 -130 0 0 {name=p54 sig_type=std_logic lab=Vc2}
C {devices/lab_pin.sym} 1240 -180 0 0 {name=p55 sig_type=std_logic lab=Vc2s}
C {devices/opin.sym} 60 -700 0 0 {name=p56 lab=Vc1s sim_pinnumber=7}
C {devices/opin.sym} 60 -670 0 0 {name=p57 lab=Vc2s sim_pinnumber=8}
C {devices/isource.sym} 1700 -290 0 0 {name=I1 value=1u only_toplevel=true}
C {devices/opin.sym} 60 -640 0 0 {name=p58 lab=Vdos sim_pinnumber=9}
